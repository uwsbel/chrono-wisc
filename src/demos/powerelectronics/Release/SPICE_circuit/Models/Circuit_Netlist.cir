!!!! CIURCUIT !!!!
RaC n5 n1 {parRaC}
LaC n4 n5 {parLaC} ic{icLaC}
VbackemfCVAR n4 n3 PWL(0.000000e+00 -2.273207e+01 1.000000e-06 -2.273338e+01 2.000000e-06 -2.273469e+01 3.000000e-06 -2.273600e+01 4.000000e-06 -2.273731e+01 5.000000e-06 -2.273862e+01 6.000000e-06 -2.273993e+01 7.000000e-06 -2.274124e+01 8.000000e-06 -2.274255e+01 9.000000e-06 -2.274386e+01 1.000000e-05 -2.274517e+01 1.100000e-05 -2.274648e+01 1.200000e-05 -2.274779e+01 1.300000e-05 -2.274910e+01 1.400000e-05 -2.275041e+01 1.500000e-05 -2.275172e+01 1.600000e-05 -2.275303e+01 1.700000e-05 -2.275434e+01 1.800000e-05 -2.275565e+01 1.900000e-05 -2.275696e+01 2.000000e-05 -2.275827e+01 2.100000e-05 -2.275958e+01 2.200000e-05 -2.276089e+01 2.300000e-05 -2.276220e+01 2.400000e-05 -2.276351e+01 2.500000e-05 -2.276482e+01 2.600000e-05 -2.276613e+01 2.700000e-05 -2.276744e+01 2.800000e-05 -2.276875e+01 2.900000e-05 -2.277006e+01 3.000000e-05 -2.277137e+01 3.100000e-05 -2.277268e+01 3.200000e-05 -2.277399e+01 3.300000e-05 -2.277530e+01 3.400000e-05 -2.277661e+01 3.500000e-05 -2.277792e+01 3.600000e-05 -2.277923e+01 3.700000e-05 -2.278054e+01 3.800000e-05 -2.278185e+01 3.900000e-05 -2.278316e+01 4.000000e-05 -2.278447e+01 4.100000e-05 -2.278578e+01 4.200000e-05 -2.278709e+01 4.300000e-05 -2.278840e+01 4.400000e-05 -2.278971e+01 4.500000e-05 -2.279102e+01 4.600000e-05 -2.279233e+01 4.700000e-05 -2.279364e+01 4.800000e-05 -2.279495e+01 4.900000e-05 -2.279626e+01 5.000000e-05 -2.279758e+01 5.100000e-05 -2.279889e+01 5.200000e-05 -2.280020e+01 5.300000e-05 -2.280151e+01 5.400000e-05 -2.280282e+01 5.500000e-05 -2.280413e+01 5.600000e-05 -2.280544e+01 5.700000e-05 -2.280675e+01 5.800000e-05 -2.280806e+01 5.900000e-05 -2.280937e+01 6.000000e-05 -2.281068e+01 6.100000e-05 -2.281199e+01 6.200000e-05 -2.281330e+01 6.300000e-05 -2.281461e+01 6.400000e-05 -2.281592e+01 6.500000e-05 -2.281723e+01 6.600000e-05 -2.281854e+01 6.700000e-05 -2.281985e+01 6.800000e-05 -2.282116e+01 6.900000e-05 -2.282247e+01 7.000000e-05 -2.282378e+01 7.100000e-05 -2.282509e+01 7.200000e-05 -2.282640e+01 7.300000e-05 -2.282771e+01 7.400000e-05 -2.282902e+01 7.500000e-05 -2.283033e+01 7.600000e-05 -2.283164e+01 7.700000e-05 -2.283295e+01 7.800000e-05 -2.283426e+01 7.900000e-05 -2.283557e+01 8.000000e-05 -2.283688e+01 8.100000e-05 -2.283819e+01 8.200000e-05 -2.283950e+01 8.300000e-05 -2.284081e+01 8.400000e-05 -2.284212e+01 8.500000e-05 -2.284343e+01 8.600000e-05 -2.284474e+01 8.700000e-05 -2.284605e+01 8.800000e-05 -2.284736e+01 8.900000e-05 -2.284867e+01 9.000000e-05 -2.284998e+01 9.100000e-05 -2.285129e+01 9.200000e-05 -2.285260e+01 9.300000e-05 -2.285391e+01 9.400000e-05 -2.285522e+01 9.500000e-05 -2.285653e+01 9.600000e-05 -2.285784e+01 9.700000e-05 -2.285915e+01 9.800000e-05 -2.286046e+01 9.900000e-05 -2.286177e+01 1.000000e-04 -2.286308e+01 1.010000e-04 -2.286439e+01 1.020000e-04 -2.286570e+01 1.030000e-04 -2.286701e+01 1.040000e-04 -2.286832e+01 1.050000e-04 -2.286963e+01 1.060000e-04 -2.287094e+01 1.070000e-04 -2.287225e+01 1.080000e-04 -2.287356e+01 1.090000e-04 -2.287487e+01 1.100000e-04 -2.287618e+01 1.110000e-04 -2.287749e+01 1.120000e-04 -2.287880e+01 1.130000e-04 -2.288011e+01 1.140000e-04 -2.288142e+01 1.150000e-04 -2.288273e+01 1.160000e-04 -2.288404e+01 1.170000e-04 -2.288535e+01 1.180000e-04 -2.288666e+01 1.190000e-04 -2.288797e+01 1.200000e-04 -2.288928e+01 1.210000e-04 -2.289059e+01 1.220000e-04 -2.289190e+01 1.230000e-04 -2.289321e+01 1.240000e-04 -2.289452e+01 1.250000e-04 -2.289583e+01 1.260000e-04 -2.289714e+01 1.270000e-04 -2.289845e+01 1.280000e-04 -2.289976e+01 1.290000e-04 -2.290107e+01 1.300000e-04 -2.290238e+01 1.310000e-04 -2.290369e+01 1.320000e-04 -2.290500e+01 1.330000e-04 -2.290631e+01 1.340000e-04 -2.290762e+01 1.350000e-04 -2.290893e+01 1.360000e-04 -2.291024e+01 1.370000e-04 -2.291155e+01 1.380000e-04 -2.291286e+01 1.390000e-04 -2.291417e+01 1.400000e-04 -2.291548e+01 1.410000e-04 -2.291679e+01 1.420000e-04 -2.291810e+01 1.430000e-04 -2.291941e+01 1.440000e-04 -2.292072e+01 1.450000e-04 -2.292203e+01 1.460000e-04 -2.292334e+01 1.470000e-04 -2.292465e+01 1.480000e-04 -2.292596e+01 1.490000e-04 -2.292727e+01 1.500000e-04 -2.292859e+01 1.510000e-04 -2.292990e+01 1.520000e-04 -2.293121e+01 1.530000e-04 -2.293252e+01 1.540000e-04 -2.293383e+01 1.550000e-04 -2.293514e+01 1.560000e-04 -2.293645e+01 1.570000e-04 -2.293776e+01 1.580000e-04 -2.293907e+01 1.590000e-04 -2.294038e+01 1.600000e-04 -2.294169e+01 1.610000e-04 -2.294300e+01 1.620000e-04 -2.294431e+01 1.630000e-04 -2.294562e+01 1.640000e-04 -2.294693e+01 1.650000e-04 -2.294824e+01 1.660000e-04 -2.294955e+01 1.670000e-04 -2.295086e+01 1.680000e-04 -2.295217e+01 1.690000e-04 -2.295348e+01 1.700000e-04 -2.295479e+01 1.710000e-04 -2.295610e+01 1.720000e-04 -2.295741e+01 1.730000e-04 -2.295872e+01 1.740000e-04 -2.296003e+01 1.750000e-04 -2.296134e+01 1.760000e-04 -2.296265e+01 1.770000e-04 -2.296396e+01 1.780000e-04 -2.296527e+01 1.790000e-04 -2.296658e+01 1.800000e-04 -2.296789e+01 1.810000e-04 -2.296920e+01 1.820000e-04 -2.297051e+01 1.830000e-04 -2.297182e+01 1.840000e-04 -2.297313e+01 1.850000e-04 -2.297444e+01 1.860000e-04 -2.297575e+01 1.870000e-04 -2.297706e+01 1.880000e-04 -2.297837e+01 1.890000e-04 -2.297968e+01 1.900000e-04 -2.298099e+01 1.910000e-04 -2.298230e+01 1.920000e-04 -2.298361e+01 1.930000e-04 -2.298492e+01 1.940000e-04 -2.298623e+01 1.950000e-04 -2.298754e+01 1.960000e-04 -2.298885e+01 1.970000e-04 -2.299016e+01 1.980000e-04 -2.299147e+01 1.990000e-04 -2.299278e+01)
Vprobe1 n2 n3 0
VgenVAR n6 0 PWL(0.000000e+00 1.500000e+01 1.000000e-06 1.500000e+01 2.000000e-06 1.500000e+01 3.000000e-06 1.500000e+01 4.000000e-06 1.500000e+01 5.000000e-06 1.500000e+01 6.000000e-06 1.500000e+01 7.000000e-06 1.500000e+01 8.000000e-06 1.500000e+01 9.000000e-06 1.500000e+01 1.000000e-05 1.500000e+01 1.100000e-05 1.500000e+01 1.200000e-05 1.500000e+01 1.300000e-05 1.500000e+01 1.400000e-05 1.500000e+01 1.500000e-05 1.500000e+01 1.600000e-05 1.500000e+01 1.700000e-05 1.500000e+01 1.800000e-05 1.500000e+01 1.900000e-05 1.500000e+01 2.000000e-05 1.500000e+01 2.100000e-05 1.500000e+01 2.200000e-05 1.500000e+01 2.300000e-05 1.500000e+01 2.400000e-05 1.500000e+01 2.500000e-05 1.500000e+01 2.600000e-05 1.500000e+01 2.700000e-05 1.500000e+01 2.800000e-05 1.500000e+01 2.900000e-05 1.500000e+01 3.000000e-05 1.500000e+01 3.100000e-05 1.500000e+01 3.200000e-05 1.500000e+01 3.300000e-05 1.500000e+01 3.400000e-05 1.500000e+01 3.500000e-05 1.500000e+01 3.600000e-05 1.500000e+01 3.700000e-05 1.500000e+01 3.800000e-05 1.500000e+01 3.900000e-05 1.500000e+01 4.000000e-05 1.500000e+01 4.100000e-05 1.500000e+01 4.200000e-05 1.500000e+01 4.300000e-05 1.500000e+01 4.400000e-05 1.500000e+01 4.500000e-05 1.500000e+01 4.600000e-05 1.500000e+01 4.700000e-05 1.500000e+01 4.800000e-05 1.500000e+01 4.900000e-05 1.500000e+01 5.000000e-05 1.500000e+01 5.100000e-05 1.500000e+01 5.200000e-05 1.500000e+01 5.300000e-05 1.500000e+01 5.400000e-05 1.500000e+01 5.500000e-05 1.500000e+01 5.600000e-05 1.500000e+01 5.700000e-05 1.500000e+01 5.800000e-05 1.500000e+01 5.900000e-05 1.500000e+01 6.000000e-05 1.500000e+01 6.100000e-05 1.500000e+01 6.200000e-05 1.500000e+01 6.300000e-05 1.500000e+01 6.400000e-05 1.500000e+01 6.500000e-05 1.500000e+01 6.600000e-05 1.500000e+01 6.700000e-05 1.500000e+01 6.800000e-05 1.500000e+01 6.900000e-05 1.500000e+01 7.000000e-05 1.500000e+01 7.100000e-05 1.500000e+01 7.200000e-05 1.500000e+01 7.300000e-05 1.500000e+01 7.400000e-05 1.500000e+01 7.500000e-05 1.500000e+01 7.600000e-05 1.500000e+01 7.700000e-05 1.500000e+01 7.800000e-05 1.500000e+01 7.900000e-05 1.500000e+01 8.000000e-05 1.500000e+01 8.100000e-05 1.500000e+01 8.200000e-05 1.500000e+01 8.300000e-05 1.500000e+01 8.400000e-05 1.500000e+01 8.500000e-05 1.500000e+01 8.600000e-05 1.500000e+01 8.700000e-05 1.500000e+01 8.800000e-05 1.500000e+01 8.900000e-05 1.500000e+01 9.000000e-05 1.500000e+01 9.100000e-05 1.500000e+01 9.200000e-05 1.500000e+01 9.300000e-05 1.500000e+01 9.400000e-05 1.500000e+01 9.500000e-05 1.500000e+01 9.600000e-05 1.500000e+01 9.700000e-05 1.500000e+01 9.800000e-05 1.500000e+01 9.900000e-05 1.500000e+01 1.000000e-04 1.500000e+01 1.010000e-04 1.500000e+01 1.020000e-04 1.500000e+01 1.030000e-04 1.500000e+01 1.040000e-04 1.500000e+01 1.050000e-04 1.500000e+01 1.060000e-04 1.500000e+01 1.070000e-04 1.500000e+01 1.080000e-04 1.500000e+01 1.090000e-04 1.500000e+01 1.100000e-04 1.500000e+01 1.110000e-04 1.500000e+01 1.120000e-04 1.500000e+01 1.130000e-04 1.500000e+01 1.140000e-04 1.500000e+01 1.150000e-04 1.500000e+01 1.160000e-04 1.500000e+01 1.170000e-04 1.500000e+01 1.180000e-04 1.500000e+01 1.190000e-04 1.500000e+01 1.200000e-04 1.500000e+01 1.210000e-04 1.500000e+01 1.220000e-04 1.500000e+01 1.230000e-04 1.500000e+01 1.240000e-04 1.500000e+01 1.250000e-04 1.500000e+01 1.260000e-04 1.500000e+01 1.270000e-04 1.500000e+01 1.280000e-04 1.500000e+01 1.290000e-04 1.500000e+01 1.300000e-04 1.500000e+01 1.310000e-04 1.500000e+01 1.320000e-04 1.500000e+01 1.330000e-04 1.500000e+01 1.340000e-04 1.500000e+01 1.350000e-04 1.500000e+01 1.360000e-04 1.500000e+01 1.370000e-04 1.500000e+01 1.380000e-04 1.500000e+01 1.390000e-04 1.500000e+01 1.400000e-04 1.500000e+01 1.410000e-04 1.500000e+01 1.420000e-04 1.500000e+01 1.430000e-04 1.500000e+01 1.440000e-04 1.500000e+01 1.450000e-04 1.500000e+01 1.460000e-04 1.500000e+01 1.470000e-04 1.500000e+01 1.480000e-04 1.500000e+01 1.490000e-04 1.500000e+01 1.500000e-04 1.500000e+01 1.510000e-04 1.500000e+01 1.520000e-04 1.500000e+01 1.530000e-04 1.500000e+01 1.540000e-04 1.500000e+01 1.550000e-04 1.500000e+01 1.560000e-04 1.500000e+01 1.570000e-04 1.500000e+01 1.580000e-04 1.500000e+01 1.590000e-04 1.500000e+01 1.600000e-04 1.500000e+01 1.610000e-04 1.500000e+01 1.620000e-04 1.500000e+01 1.630000e-04 1.500000e+01 1.640000e-04 1.500000e+01 1.650000e-04 1.500000e+01 1.660000e-04 1.500000e+01 1.670000e-04 1.500000e+01 1.680000e-04 1.500000e+01 1.690000e-04 1.500000e+01 1.700000e-04 1.500000e+01 1.710000e-04 1.500000e+01 1.720000e-04 1.500000e+01 1.730000e-04 1.500000e+01 1.740000e-04 1.500000e+01 1.750000e-04 1.500000e+01 1.760000e-04 1.500000e+01 1.770000e-04 1.500000e+01 1.780000e-04 1.500000e+01 1.790000e-04 1.500000e+01 1.800000e-04 1.500000e+01 1.810000e-04 1.500000e+01 1.820000e-04 1.500000e+01 1.830000e-04 1.500000e+01 1.840000e-04 1.500000e+01 1.850000e-04 1.500000e+01 1.860000e-04 1.500000e+01 1.870000e-04 1.500000e+01 1.880000e-04 1.500000e+01 1.890000e-04 1.500000e+01 1.900000e-04 1.500000e+01 1.910000e-04 1.500000e+01 1.920000e-04 1.500000e+01 1.930000e-04 1.500000e+01 1.940000e-04 1.500000e+01 1.950000e-04 1.500000e+01 1.960000e-04 1.500000e+01 1.970000e-04 1.500000e+01 1.980000e-04 1.500000e+01 1.990000e-04 1.500000e+01)
S1 n12 n6 n10 0 SW1
VSW1VAR n10 0 PWL(0.000000e+00 1.000000e+00 1.000000e-06 1.000000e+00 2.000000e-06 1.000000e+00 3.000000e-06 1.000000e+00 4.000000e-06 1.000000e+00 5.000000e-06 1.000000e+00 6.000000e-06 1.000000e+00 7.000000e-06 1.000000e+00 8.000000e-06 1.000000e+00 9.000000e-06 1.000000e+00 1.000000e-05 1.000000e+00 1.100000e-05 1.000000e+00 1.200000e-05 1.000000e+00 1.300000e-05 1.000000e+00 1.400000e-05 1.000000e+00 1.500000e-05 1.000000e+00 1.600000e-05 1.000000e+00 1.700000e-05 1.000000e+00 1.800000e-05 1.000000e+00 1.900000e-05 1.000000e+00 2.000000e-05 1.000000e+00 2.100000e-05 1.000000e+00 2.200000e-05 1.000000e+00 2.300000e-05 1.000000e+00 2.400000e-05 1.000000e+00 2.500000e-05 1.000000e+00 2.600000e-05 1.000000e+00 2.700000e-05 1.000000e+00 2.800000e-05 1.000000e+00 2.900000e-05 1.000000e+00 3.000000e-05 1.000000e+00 3.100000e-05 1.000000e+00 3.200000e-05 1.000000e+00 3.300000e-05 1.000000e+00 3.400000e-05 1.000000e+00 3.500000e-05 1.000000e+00 3.600000e-05 1.000000e+00 3.700000e-05 1.000000e+00 3.800000e-05 1.000000e+00 3.900000e-05 1.000000e+00 4.000000e-05 1.000000e+00 4.100000e-05 1.000000e+00 4.200000e-05 1.000000e+00 4.300000e-05 1.000000e+00 4.400000e-05 1.000000e+00 4.500000e-05 1.000000e+00 4.600000e-05 1.000000e+00 4.700000e-05 1.000000e+00 4.800000e-05 1.000000e+00 4.900000e-05 1.000000e+00 5.000000e-05 1.000000e+00 5.100000e-05 1.000000e+00 5.200000e-05 1.000000e+00 5.300000e-05 1.000000e+00 5.400000e-05 1.000000e+00 5.500000e-05 1.000000e+00 5.600000e-05 1.000000e+00 5.700000e-05 1.000000e+00 5.800000e-05 1.000000e+00 5.900000e-05 1.000000e+00 6.000000e-05 1.000000e+00 6.100000e-05 1.000000e+00 6.200000e-05 1.000000e+00 6.300000e-05 1.000000e+00 6.400000e-05 1.000000e+00 6.500000e-05 1.000000e+00 6.600000e-05 1.000000e+00 6.700000e-05 1.000000e+00 6.800000e-05 1.000000e+00 6.900000e-05 1.000000e+00 7.000000e-05 1.000000e+00 7.100000e-05 1.000000e+00 7.200000e-05 1.000000e+00 7.300000e-05 1.000000e+00 7.400000e-05 1.000000e+00 7.500000e-05 1.000000e+00 7.600000e-05 1.000000e+00 7.700000e-05 1.000000e+00 7.800000e-05 1.000000e+00 7.900000e-05 1.000000e+00 8.000000e-05 1.000000e+00 8.100000e-05 1.000000e+00 8.200000e-05 1.000000e+00 8.300000e-05 1.000000e+00 8.400000e-05 1.000000e+00 8.500000e-05 1.000000e+00 8.600000e-05 1.000000e+00 8.700000e-05 1.000000e+00 8.800000e-05 1.000000e+00 8.900000e-05 1.000000e+00 9.000000e-05 1.000000e+00 9.100000e-05 1.000000e+00 9.200000e-05 1.000000e+00 9.300000e-05 1.000000e+00 9.400000e-05 1.000000e+00 9.500000e-05 1.000000e+00 9.600000e-05 1.000000e+00 9.700000e-05 1.000000e+00 9.800000e-05 1.000000e+00 9.900000e-05 1.000000e+00 1.000000e-04 1.000000e+00 1.010000e-04 1.000000e+00 1.020000e-04 1.000000e+00 1.030000e-04 1.000000e+00 1.040000e-04 1.000000e+00 1.050000e-04 1.000000e+00 1.060000e-04 1.000000e+00 1.070000e-04 1.000000e+00 1.080000e-04 1.000000e+00 1.090000e-04 1.000000e+00 1.100000e-04 1.000000e+00 1.110000e-04 1.000000e+00 1.120000e-04 1.000000e+00 1.130000e-04 1.000000e+00 1.140000e-04 1.000000e+00 1.150000e-04 1.000000e+00 1.160000e-04 1.000000e+00 1.170000e-04 1.000000e+00 1.180000e-04 1.000000e+00 1.190000e-04 1.000000e+00 1.200000e-04 1.000000e+00 1.210000e-04 1.000000e+00 1.220000e-04 1.000000e+00 1.230000e-04 1.000000e+00 1.240000e-04 1.000000e+00 1.250000e-04 1.000000e+00 1.260000e-04 1.000000e+00 1.270000e-04 1.000000e+00 1.280000e-04 1.000000e+00 1.290000e-04 1.000000e+00 1.300000e-04 1.000000e+00 1.310000e-04 1.000000e+00 1.320000e-04 1.000000e+00 1.330000e-04 1.000000e+00 1.340000e-04 1.000000e+00 1.350000e-04 1.000000e+00 1.360000e-04 1.000000e+00 1.370000e-04 1.000000e+00 1.380000e-04 1.000000e+00 1.390000e-04 1.000000e+00 1.400000e-04 1.000000e+00 1.410000e-04 1.000000e+00 1.420000e-04 1.000000e+00 1.430000e-04 1.000000e+00 1.440000e-04 1.000000e+00 1.450000e-04 1.000000e+00 1.460000e-04 1.000000e+00 1.470000e-04 1.000000e+00 1.480000e-04 1.000000e+00 1.490000e-04 1.000000e+00 1.500000e-04 1.000000e+00 1.510000e-04 1.000000e+00 1.520000e-04 1.000000e+00 1.530000e-04 1.000000e+00 1.540000e-04 1.000000e+00 1.550000e-04 1.000000e+00 1.560000e-04 1.000000e+00 1.570000e-04 1.000000e+00 1.580000e-04 1.000000e+00 1.590000e-04 1.000000e+00 1.600000e-04 1.000000e+00 1.610000e-04 1.000000e+00 1.620000e-04 1.000000e+00 1.630000e-04 1.000000e+00 1.640000e-04 1.000000e+00 1.650000e-04 1.000000e+00 1.660000e-04 1.000000e+00 1.670000e-04 1.000000e+00 1.680000e-04 1.000000e+00 1.690000e-04 1.000000e+00 1.700000e-04 1.000000e+00 1.710000e-04 1.000000e+00 1.720000e-04 1.000000e+00 1.730000e-04 1.000000e+00 1.740000e-04 1.000000e+00 1.750000e-04 1.000000e+00 1.760000e-04 1.000000e+00 1.770000e-04 1.000000e+00 1.780000e-04 1.000000e+00 1.790000e-04 1.000000e+00 1.800000e-04 1.000000e+00 1.810000e-04 1.000000e+00 1.820000e-04 1.000000e+00 1.830000e-04 1.000000e+00 1.840000e-04 1.000000e+00 1.850000e-04 1.000000e+00 1.860000e-04 1.000000e+00 1.870000e-04 1.000000e+00 1.880000e-04 1.000000e+00 1.890000e-04 1.000000e+00 1.900000e-04 1.000000e+00 1.910000e-04 1.000000e+00 1.920000e-04 1.000000e+00 1.930000e-04 1.000000e+00 1.940000e-04 1.000000e+00 1.950000e-04 1.000000e+00 1.960000e-04 1.000000e+00 1.970000e-04 1.000000e+00 1.980000e-04 1.000000e+00 1.990000e-04 1.000000e+00)
X1 n1 n8 n7 irf520
D1 n1 n2 DI_1N4007
C1 n2 n11 12e-6
R8 n11 n1 25
R1 n7 0 2
R3 n12 n2 15
VgenPWMVAR n8 0 PWL(0.000000e+00 5.200000e+00 1.000000e-06 5.200000e+00 2.000000e-06 5.200000e+00 3.000000e-06 5.200000e+00 4.000000e-06 5.200000e+00 5.000000e-06 5.200000e+00 6.000000e-06 5.200000e+00 7.000000e-06 5.200000e+00 8.000000e-06 5.200000e+00 9.000000e-06 5.200000e+00 1.000000e-05 5.200000e+00 1.100000e-05 5.200000e+00 1.200000e-05 5.200000e+00 1.300000e-05 5.200000e+00 1.400000e-05 5.200000e+00 1.500000e-05 5.200000e+00 1.600000e-05 5.200000e+00 1.700000e-05 5.200000e+00 1.800000e-05 5.200000e+00 1.900000e-05 5.200000e+00 2.000000e-05 5.200000e+00 2.100000e-05 5.200000e+00 2.200000e-05 5.200000e+00 2.300000e-05 5.200000e+00 2.400000e-05 5.200000e+00 2.500000e-05 5.200000e+00 2.600000e-05 5.200000e+00 2.700000e-05 5.200000e+00 2.800000e-05 5.200000e+00 2.900000e-05 5.200000e+00 3.000000e-05 5.200000e+00 3.100000e-05 5.200000e+00 3.200000e-05 5.200000e+00 3.300000e-05 5.200000e+00 3.400000e-05 5.200000e+00 3.500000e-05 5.200000e+00 3.600000e-05 5.200000e+00 3.700000e-05 5.200000e+00 3.800000e-05 5.200000e+00 3.900000e-05 5.200000e+00 4.000000e-05 5.200000e+00 4.100000e-05 5.200000e+00 4.200000e-05 5.200000e+00 4.300000e-05 5.200000e+00 4.400000e-05 5.200000e+00 4.500000e-05 5.200000e+00 4.600000e-05 5.200000e+00 4.700000e-05 5.200000e+00 4.800000e-05 5.200000e+00 4.900000e-05 5.200000e+00 5.000000e-05 5.200000e+00 5.100000e-05 5.200000e+00 5.200000e-05 5.200000e+00 5.300000e-05 5.200000e+00 5.400000e-05 5.200000e+00 5.500000e-05 5.200000e+00 5.600000e-05 5.200000e+00 5.700000e-05 5.200000e+00 5.800000e-05 5.200000e+00 5.900000e-05 5.200000e+00 6.000000e-05 5.200000e+00 6.100000e-05 5.200000e+00 6.200000e-05 5.200000e+00 6.300000e-05 5.200000e+00 6.400000e-05 5.200000e+00 6.500000e-05 5.200000e+00 6.600000e-05 5.200000e+00 6.700000e-05 5.200000e+00 6.800000e-05 5.200000e+00 6.900000e-05 5.200000e+00 7.000000e-05 5.200000e+00 7.100000e-05 5.200000e+00 7.200000e-05 5.200000e+00 7.300000e-05 5.200000e+00 7.400000e-05 5.200000e+00 7.500000e-05 5.200000e+00 7.600000e-05 5.200000e+00 7.700000e-05 5.200000e+00 7.800000e-05 5.200000e+00 7.900000e-05 5.200000e+00 8.000000e-05 5.200000e+00 8.100000e-05 5.200000e+00 8.200000e-05 5.200000e+00 8.300000e-05 5.200000e+00 8.400000e-05 5.200000e+00 8.500000e-05 5.200000e+00 8.600000e-05 5.200000e+00 8.700000e-05 5.200000e+00 8.800000e-05 5.200000e+00 8.900000e-05 5.200000e+00 9.000000e-05 5.200000e+00 9.100000e-05 5.200000e+00 9.200000e-05 5.200000e+00 9.300000e-05 5.200000e+00 9.400000e-05 5.200000e+00 9.500000e-05 5.200000e+00 9.600000e-05 5.200000e+00 9.700000e-05 5.200000e+00 9.800000e-05 5.200000e+00 9.900000e-05 5.200000e+00 1.000000e-04 5.200000e+00 1.010000e-04 5.200000e+00 1.020000e-04 5.200000e+00 1.030000e-04 5.200000e+00 1.040000e-04 5.200000e+00 1.050000e-04 5.200000e+00 1.060000e-04 5.200000e+00 1.070000e-04 5.200000e+00 1.080000e-04 5.200000e+00 1.090000e-04 5.200000e+00 1.100000e-04 5.200000e+00 1.110000e-04 5.200000e+00 1.120000e-04 5.200000e+00 1.130000e-04 5.200000e+00 1.140000e-04 5.200000e+00 1.150000e-04 5.200000e+00 1.160000e-04 5.200000e+00 1.170000e-04 5.200000e+00 1.180000e-04 5.200000e+00 1.190000e-04 5.200000e+00 1.200000e-04 5.200000e+00 1.210000e-04 5.200000e+00 1.220000e-04 5.200000e+00 1.230000e-04 5.200000e+00 1.240000e-04 5.200000e+00 1.250000e-04 5.200000e+00 1.260000e-04 5.200000e+00 1.270000e-04 5.200000e+00 1.280000e-04 5.200000e+00 1.290000e-04 5.200000e+00 1.300000e-04 5.200000e+00 1.310000e-04 5.200000e+00 1.320000e-04 5.200000e+00 1.330000e-04 5.200000e+00 1.340000e-04 5.200000e+00 1.350000e-04 5.200000e+00 1.360000e-04 5.200000e+00 1.370000e-04 5.200000e+00 1.380000e-04 5.200000e+00 1.390000e-04 5.200000e+00 1.400000e-04 5.200000e+00 1.410000e-04 5.200000e+00 1.420000e-04 5.200000e+00 1.430000e-04 5.200000e+00 1.440000e-04 5.200000e+00 1.450000e-04 5.200000e+00 1.460000e-04 5.200000e+00 1.470000e-04 5.200000e+00 1.480000e-04 5.200000e+00 1.490000e-04 5.200000e+00 1.500000e-04 5.200000e+00 1.510000e-04 5.200000e+00 1.520000e-04 5.200000e+00 1.530000e-04 5.200000e+00 1.540000e-04 5.200000e+00 1.550000e-04 5.200000e+00 1.560000e-04 5.200000e+00 1.570000e-04 5.200000e+00 1.580000e-04 5.200000e+00 1.590000e-04 5.200000e+00 1.600000e-04 5.200000e+00 1.610000e-04 5.200000e+00 1.620000e-04 5.200000e+00 1.630000e-04 5.200000e+00 1.640000e-04 5.200000e+00 1.650000e-04 5.200000e+00 1.660000e-04 5.200000e+00 1.670000e-04 5.200000e+00 1.680000e-04 5.200000e+00 1.690000e-04 5.200000e+00 1.700000e-04 5.200000e+00 1.710000e-04 5.200000e+00 1.720000e-04 5.200000e+00 1.730000e-04 5.200000e+00 1.740000e-04 5.200000e+00 1.750000e-04 5.200000e+00 1.760000e-04 5.200000e+00 1.770000e-04 5.200000e+00 1.780000e-04 5.200000e+00 1.790000e-04 5.200000e+00 1.800000e-04 5.200000e+00 1.810000e-04 5.200000e+00 1.820000e-04 5.200000e+00 1.830000e-04 5.200000e+00 1.840000e-04 5.200000e+00 1.850000e-04 5.200000e+00 1.860000e-04 5.200000e+00 1.870000e-04 5.200000e+00 1.880000e-04 5.200000e+00 1.890000e-04 5.200000e+00 1.900000e-04 5.200000e+00 1.910000e-04 5.200000e+00 1.920000e-04 5.200000e+00 1.930000e-04 5.200000e+00 1.940000e-04 5.200000e+00 1.950000e-04 5.200000e+00 1.960000e-04 5.200000e+00 1.970000e-04 5.200000e+00 1.980000e-04 5.200000e+00 1.990000e-04 5.200000e+00)
R2 n8 0 10e3
VMos1 n9 0 25
.param parVgenVAR=1.500000e+01
.param parVbackemfCVAR=-2.299278e+01
.param parLaC=2.000000e-03
.param parRaC=6.910000e+01
.param parVSW1VAR=1.000000e+00
.param parVgenPWMVAR=5.200000e+00
.param icLaC=1.630664e-01
.ic V(n9)=2.500000e+01 V(n11)=5.396183e-01 V(x1.6)=-2.521998e-01 V(x1.11)=-2.521998e-01 V(x1.10)=-4.798411e+00 V(x1.5)=-2.522134e-01 V(x1.4)=0.000000e+00 V(n8)=5.200000e+00 V(n7)=3.369767e-01 V(x1.8)=3.657958e-01 V(x1.7)=5.200000e+00 V(x1.9)=4.015889e-01 V(n10)=1.000000e+00 V(n12)=1.498315e+01 V(n6)=1.500000e+01 V(n2)=1.245583e+01 V(n3)=1.245583e+01 V(n4)=1.165988e+01 V(n1)=4.040708e-01 V(n5)=1.167196e+01
**********MODELS**********
*****MODEL1*****
.model SW1 SW(Ron=0.1 Roff=1Meg Vt=.5 Vh=0)
*****MODEL2*****
.MODEL DI_1N4007 D  ( IS=76.9p RS=42.0m BV=1.00k IBV=5.00u
+ CJO=26.5p  M=0.333 N=1.45 TT=4.32u )
*****MODEL3*****
.SUBCKT irf520 1 2 3
**************************************
*      Model Generated by MODPEX     *
*Copyright(c) Symmetry Design Systems*
*         All Rights Reserved        *
*    UNPUBLISHED LICENSED SOFTWARE   *
*   Contains Proprietary Information *
*      Which is The Property of      *
*     SYMMETRY OR ITS LICENSORS      *
*Commercial Use or Resale Restricted *
*   by Symmetry License Agreement    *
**************************************
* Model generated on Apr 24, 96
* Model format: SPICE3
* Symmetry POWER MOS Model (Version 1.0)
* External Node Designations
* Node 1 -> Drain
* Node 2 -> Gate
* Node 3 -> Source
M1 9 7 8 8 MM L=100u W=100u
* Default values used in MM:
* The voltage-dependent capacitances are
* not included. Other default values are:
*   RS=0 RD=0 LD=0 CBD=0 CBS=0 CGBO=0
.MODEL MM NMOS LEVEL=1 IS=1e-32
+VTO=3.61397 LAMBDA=0.00572642 KP=3.9143
+CGSO=3.28344e-06 CGDO=1.0112e-11
RS 8 3 0.171045
D1 3 1 MD
.MODEL MD D IS=7.10668e-11 RS=0.0302634 N=1.21428 BV=100
+IBV=0.00025 EG=1 XTI=2.99378 TT=2.27818e-09
+CJO=5.01988e-10 VJ=0.565258 M=0.378444 FC=0.5
RDS 3 1 4e+06
RD 9 1 0.01473
RG 2 7 1.34402
D2 4 5 MD1
* Default values used in MD1:
*   RS=0 EG=1.11 XTI=3.0 TT=0
*   BV=infinite IBV=1mA
.MODEL MD1 D IS=1e-32 N=50
+CJO=4.14565e-10 VJ=0.5 M=0.640575 FC=1e-08
D3 0 5 MD2
* Default values used in MD2:
*   EG=1.11 XTI=3.0 TT=0 CJO=0
*   BV=infinite IBV=1mA
.MODEL MD2 D IS=1e-10 N=0.4 RS=3e-06
RL 5 10 1
FI2 7 9 VFI2 -1
VFI2 4 0 0
EV16 10 0 9 7 1
CAP 11 10 6.23795e-10
FI1 7 9 VFI1 -1
VFI1 11 6 0
RCAP 6 10 1
D4 0 6 MD3
* Default values used in MD3:
*   EG=1.11 XTI=3.0 TT=0 CJO=0
*   RS=0 BV=infinite IBV=1mA
.MODEL MD3 D IS=1e-10 N=0.4
.ENDS
