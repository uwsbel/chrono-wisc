!!!! CIURCUIT !!!!
RaC n5 n1 {parRaC}
LaC n4 n5 {parLaC} ic{icLaC}
VbackemfCVAR n4 n3 PWL(0.000000e+00 -7.959512e-01 1.000000e-06 -7.966507e-01 2.000000e-06 -7.973501e-01 3.000000e-06 -7.980496e-01 4.000000e-06 -7.987490e-01 5.000000e-06 -7.994485e-01 6.000000e-06 -8.001480e-01 7.000000e-06 -8.008474e-01 8.000000e-06 -8.015469e-01 9.000000e-06 -8.022463e-01 1.000000e-05 -8.029458e-01 1.100000e-05 -8.036453e-01 1.200000e-05 -8.043447e-01 1.300000e-05 -8.050442e-01 1.400000e-05 -8.057436e-01 1.500000e-05 -8.064431e-01 1.600000e-05 -8.071425e-01 1.700000e-05 -8.078420e-01 1.800000e-05 -8.085415e-01 1.900000e-05 -8.092409e-01 2.000000e-05 -8.099404e-01 2.100000e-05 -8.106398e-01 2.200000e-05 -8.113393e-01 2.300000e-05 -8.120388e-01 2.400000e-05 -8.127382e-01 2.500000e-05 -8.134377e-01 2.600000e-05 -8.141371e-01 2.700000e-05 -8.148366e-01 2.800000e-05 -8.155361e-01 2.900000e-05 -8.162355e-01 3.000000e-05 -8.169350e-01 3.100000e-05 -8.176344e-01 3.200000e-05 -8.183339e-01 3.300000e-05 -8.190334e-01 3.400000e-05 -8.197328e-01 3.500000e-05 -8.204323e-01 3.600000e-05 -8.211317e-01 3.700000e-05 -8.218312e-01 3.800000e-05 -8.225307e-01 3.900000e-05 -8.232301e-01 4.000000e-05 -8.239296e-01 4.100000e-05 -8.246290e-01 4.200000e-05 -8.253285e-01 4.300000e-05 -8.260279e-01 4.400000e-05 -8.267274e-01 4.500000e-05 -8.274269e-01 4.600000e-05 -8.281263e-01 4.700000e-05 -8.288258e-01 4.800000e-05 -8.295252e-01 4.900000e-05 -8.302247e-01 5.000000e-05 -8.309242e-01 5.100000e-05 -8.316236e-01 5.200000e-05 -8.323231e-01 5.300000e-05 -8.330225e-01 5.400000e-05 -8.337220e-01 5.500000e-05 -8.344215e-01 5.600000e-05 -8.351209e-01 5.700000e-05 -8.358204e-01 5.800000e-05 -8.365198e-01 5.900000e-05 -8.372193e-01 6.000000e-05 -8.379188e-01 6.100000e-05 -8.386182e-01 6.200000e-05 -8.393177e-01 6.300000e-05 -8.400171e-01 6.400000e-05 -8.407166e-01 6.500000e-05 -8.414161e-01 6.600000e-05 -8.421155e-01 6.700000e-05 -8.428150e-01 6.800000e-05 -8.435144e-01 6.900000e-05 -8.442139e-01 7.000000e-05 -8.449134e-01 7.100000e-05 -8.456128e-01 7.200000e-05 -8.463123e-01 7.300000e-05 -8.470117e-01 7.400000e-05 -8.477112e-01 7.500000e-05 -8.484106e-01 7.600000e-05 -8.491101e-01 7.700000e-05 -8.498096e-01 7.800000e-05 -8.505090e-01 7.900000e-05 -8.512085e-01 8.000000e-05 -8.519079e-01 8.100000e-05 -8.526074e-01 8.200000e-05 -8.533069e-01 8.300000e-05 -8.540063e-01 8.400000e-05 -8.547058e-01 8.500000e-05 -8.554052e-01 8.600000e-05 -8.561047e-01 8.700000e-05 -8.568042e-01 8.800000e-05 -8.575036e-01 8.900000e-05 -8.582031e-01 9.000000e-05 -8.589025e-01 9.100000e-05 -8.596020e-01 9.200000e-05 -8.603015e-01 9.300000e-05 -8.610009e-01 9.400000e-05 -8.617004e-01 9.500000e-05 -8.623998e-01 9.600000e-05 -8.630993e-01 9.700000e-05 -8.637988e-01 9.800000e-05 -8.644982e-01 9.900000e-05 -8.651977e-01 1.000000e-04 -8.658971e-01 1.010000e-04 -8.665966e-01 1.020000e-04 -8.672960e-01 1.030000e-04 -8.679955e-01 1.040000e-04 -8.686950e-01 1.050000e-04 -8.693944e-01 1.060000e-04 -8.700939e-01 1.070000e-04 -8.707933e-01 1.080000e-04 -8.714928e-01 1.090000e-04 -8.721923e-01 1.100000e-04 -8.728917e-01 1.110000e-04 -8.735912e-01 1.120000e-04 -8.742906e-01 1.130000e-04 -8.749901e-01 1.140000e-04 -8.756896e-01 1.150000e-04 -8.763890e-01 1.160000e-04 -8.770885e-01 1.170000e-04 -8.777879e-01 1.180000e-04 -8.784874e-01 1.190000e-04 -8.791869e-01 1.200000e-04 -8.798863e-01 1.210000e-04 -8.805858e-01 1.220000e-04 -8.812852e-01 1.230000e-04 -8.819847e-01 1.240000e-04 -8.826842e-01 1.250000e-04 -8.833836e-01 1.260000e-04 -8.840831e-01 1.270000e-04 -8.847825e-01 1.280000e-04 -8.854820e-01 1.290000e-04 -8.861814e-01 1.300000e-04 -8.868809e-01 1.310000e-04 -8.875804e-01 1.320000e-04 -8.882798e-01 1.330000e-04 -8.889793e-01 1.340000e-04 -8.896787e-01 1.350000e-04 -8.903782e-01 1.360000e-04 -8.910777e-01 1.370000e-04 -8.917771e-01 1.380000e-04 -8.924766e-01 1.390000e-04 -8.931760e-01 1.400000e-04 -8.938755e-01 1.410000e-04 -8.945750e-01 1.420000e-04 -8.952744e-01 1.430000e-04 -8.959739e-01 1.440000e-04 -8.966733e-01 1.450000e-04 -8.973728e-01 1.460000e-04 -8.980723e-01 1.470000e-04 -8.987717e-01 1.480000e-04 -8.994712e-01 1.490000e-04 -9.001706e-01 1.500000e-04 -9.008701e-01 1.510000e-04 -9.015696e-01 1.520000e-04 -9.022690e-01 1.530000e-04 -9.029685e-01 1.540000e-04 -9.036679e-01 1.550000e-04 -9.043674e-01 1.560000e-04 -9.050669e-01 1.570000e-04 -9.057663e-01 1.580000e-04 -9.064658e-01 1.590000e-04 -9.071652e-01 1.600000e-04 -9.078647e-01 1.610000e-04 -9.085641e-01 1.620000e-04 -9.092636e-01 1.630000e-04 -9.099631e-01 1.640000e-04 -9.106625e-01 1.650000e-04 -9.113620e-01 1.660000e-04 -9.120614e-01 1.670000e-04 -9.127609e-01 1.680000e-04 -9.134604e-01 1.690000e-04 -9.141598e-01 1.700000e-04 -9.148593e-01 1.710000e-04 -9.155587e-01 1.720000e-04 -9.162582e-01 1.730000e-04 -9.169577e-01 1.740000e-04 -9.176571e-01 1.750000e-04 -9.183566e-01 1.760000e-04 -9.190560e-01 1.770000e-04 -9.197555e-01 1.780000e-04 -9.204550e-01 1.790000e-04 -9.211544e-01 1.800000e-04 -9.218539e-01 1.810000e-04 -9.225533e-01 1.820000e-04 -9.232528e-01 1.830000e-04 -9.239523e-01 1.840000e-04 -9.246517e-01 1.850000e-04 -9.253512e-01 1.860000e-04 -9.260506e-01 1.870000e-04 -9.267501e-01 1.880000e-04 -9.274495e-01 1.890000e-04 -9.281490e-01 1.900000e-04 -9.288485e-01 1.910000e-04 -9.295479e-01 1.920000e-04 -9.302474e-01 1.930000e-04 -9.309468e-01 1.940000e-04 -9.316463e-01 1.950000e-04 -9.323458e-01 1.960000e-04 -9.330452e-01 1.970000e-04 -9.337447e-01 1.980000e-04 -9.344441e-01 1.990000e-04 -9.351436e-01)
Vprobe1 n2 n3 0
VgenVAR n6 0 PWL(0.000000e+00 1.500000e+01 1.000000e-06 1.500000e+01 2.000000e-06 1.500000e+01 3.000000e-06 1.500000e+01 4.000000e-06 1.500000e+01 5.000000e-06 1.500000e+01 6.000000e-06 1.500000e+01 7.000000e-06 1.500000e+01 8.000000e-06 1.500000e+01 9.000000e-06 1.500000e+01 1.000000e-05 1.500000e+01 1.100000e-05 1.500000e+01 1.200000e-05 1.500000e+01 1.300000e-05 1.500000e+01 1.400000e-05 1.500000e+01 1.500000e-05 1.500000e+01 1.600000e-05 1.500000e+01 1.700000e-05 1.500000e+01 1.800000e-05 1.500000e+01 1.900000e-05 1.500000e+01 2.000000e-05 1.500000e+01 2.100000e-05 1.500000e+01 2.200000e-05 1.500000e+01 2.300000e-05 1.500000e+01 2.400000e-05 1.500000e+01 2.500000e-05 1.500000e+01 2.600000e-05 1.500000e+01 2.700000e-05 1.500000e+01 2.800000e-05 1.500000e+01 2.900000e-05 1.500000e+01 3.000000e-05 1.500000e+01 3.100000e-05 1.500000e+01 3.200000e-05 1.500000e+01 3.300000e-05 1.500000e+01 3.400000e-05 1.500000e+01 3.500000e-05 1.500000e+01 3.600000e-05 1.500000e+01 3.700000e-05 1.500000e+01 3.800000e-05 1.500000e+01 3.900000e-05 1.500000e+01 4.000000e-05 1.500000e+01 4.100000e-05 1.500000e+01 4.200000e-05 1.500000e+01 4.300000e-05 1.500000e+01 4.400000e-05 1.500000e+01 4.500000e-05 1.500000e+01 4.600000e-05 1.500000e+01 4.700000e-05 1.500000e+01 4.800000e-05 1.500000e+01 4.900000e-05 1.500000e+01 5.000000e-05 1.500000e+01 5.100000e-05 1.500000e+01 5.200000e-05 1.500000e+01 5.300000e-05 1.500000e+01 5.400000e-05 1.500000e+01 5.500000e-05 1.500000e+01 5.600000e-05 1.500000e+01 5.700000e-05 1.500000e+01 5.800000e-05 1.500000e+01 5.900000e-05 1.500000e+01 6.000000e-05 1.500000e+01 6.100000e-05 1.500000e+01 6.200000e-05 1.500000e+01 6.300000e-05 1.500000e+01 6.400000e-05 1.500000e+01 6.500000e-05 1.500000e+01 6.600000e-05 1.500000e+01 6.700000e-05 1.500000e+01 6.800000e-05 1.500000e+01 6.900000e-05 1.500000e+01 7.000000e-05 1.500000e+01 7.100000e-05 1.500000e+01 7.200000e-05 1.500000e+01 7.300000e-05 1.500000e+01 7.400000e-05 1.500000e+01 7.500000e-05 1.500000e+01 7.600000e-05 1.500000e+01 7.700000e-05 1.500000e+01 7.800000e-05 1.500000e+01 7.900000e-05 1.500000e+01 8.000000e-05 1.500000e+01 8.100000e-05 1.500000e+01 8.200000e-05 1.500000e+01 8.300000e-05 1.500000e+01 8.400000e-05 1.500000e+01 8.500000e-05 1.500000e+01 8.600000e-05 1.500000e+01 8.700000e-05 1.500000e+01 8.800000e-05 1.500000e+01 8.900000e-05 1.500000e+01 9.000000e-05 1.500000e+01 9.100000e-05 1.500000e+01 9.200000e-05 1.500000e+01 9.300000e-05 1.500000e+01 9.400000e-05 1.500000e+01 9.500000e-05 1.500000e+01 9.600000e-05 1.500000e+01 9.700000e-05 1.500000e+01 9.800000e-05 1.500000e+01 9.900000e-05 1.500000e+01 1.000000e-04 1.500000e+01 1.010000e-04 1.500000e+01 1.020000e-04 1.500000e+01 1.030000e-04 1.500000e+01 1.040000e-04 1.500000e+01 1.050000e-04 1.500000e+01 1.060000e-04 1.500000e+01 1.070000e-04 1.500000e+01 1.080000e-04 1.500000e+01 1.090000e-04 1.500000e+01 1.100000e-04 1.500000e+01 1.110000e-04 1.500000e+01 1.120000e-04 1.500000e+01 1.130000e-04 1.500000e+01 1.140000e-04 1.500000e+01 1.150000e-04 1.500000e+01 1.160000e-04 1.500000e+01 1.170000e-04 1.500000e+01 1.180000e-04 1.500000e+01 1.190000e-04 1.500000e+01 1.200000e-04 1.500000e+01 1.210000e-04 1.500000e+01 1.220000e-04 1.500000e+01 1.230000e-04 1.500000e+01 1.240000e-04 1.500000e+01 1.250000e-04 1.500000e+01 1.260000e-04 1.500000e+01 1.270000e-04 1.500000e+01 1.280000e-04 1.500000e+01 1.290000e-04 1.500000e+01 1.300000e-04 1.500000e+01 1.310000e-04 1.500000e+01 1.320000e-04 1.500000e+01 1.330000e-04 1.500000e+01 1.340000e-04 1.500000e+01 1.350000e-04 1.500000e+01 1.360000e-04 1.500000e+01 1.370000e-04 1.500000e+01 1.380000e-04 1.500000e+01 1.390000e-04 1.500000e+01 1.400000e-04 1.500000e+01 1.410000e-04 1.500000e+01 1.420000e-04 1.500000e+01 1.430000e-04 1.500000e+01 1.440000e-04 1.500000e+01 1.450000e-04 1.500000e+01 1.460000e-04 1.500000e+01 1.470000e-04 1.500000e+01 1.480000e-04 1.500000e+01 1.490000e-04 1.500000e+01 1.500000e-04 1.500000e+01 1.510000e-04 1.500000e+01 1.520000e-04 1.500000e+01 1.530000e-04 1.500000e+01 1.540000e-04 1.500000e+01 1.550000e-04 1.500000e+01 1.560000e-04 1.500000e+01 1.570000e-04 1.500000e+01 1.580000e-04 1.500000e+01 1.590000e-04 1.500000e+01 1.600000e-04 1.500000e+01 1.610000e-04 1.500000e+01 1.620000e-04 1.500000e+01 1.630000e-04 1.500000e+01 1.640000e-04 1.500000e+01 1.650000e-04 1.500000e+01 1.660000e-04 1.500000e+01 1.670000e-04 1.500000e+01 1.680000e-04 1.500000e+01 1.690000e-04 1.500000e+01 1.700000e-04 1.500000e+01 1.710000e-04 1.500000e+01 1.720000e-04 1.500000e+01 1.730000e-04 1.500000e+01 1.740000e-04 1.500000e+01 1.750000e-04 1.500000e+01 1.760000e-04 1.500000e+01 1.770000e-04 1.500000e+01 1.780000e-04 1.500000e+01 1.790000e-04 1.500000e+01 1.800000e-04 1.500000e+01 1.810000e-04 1.500000e+01 1.820000e-04 1.500000e+01 1.830000e-04 1.500000e+01 1.840000e-04 1.500000e+01 1.850000e-04 1.500000e+01 1.860000e-04 1.500000e+01 1.870000e-04 1.500000e+01 1.880000e-04 1.500000e+01 1.890000e-04 1.500000e+01 1.900000e-04 1.500000e+01 1.910000e-04 1.500000e+01 1.920000e-04 1.500000e+01 1.930000e-04 1.500000e+01 1.940000e-04 1.500000e+01 1.950000e-04 1.500000e+01 1.960000e-04 1.500000e+01 1.970000e-04 1.500000e+01 1.980000e-04 1.500000e+01 1.990000e-04 1.500000e+01)
S1 n12 n6 n10 0 SW1
VSW1VAR n10 0 PWL(0.000000e+00 1.000000e+00 1.000000e-06 1.000000e+00 2.000000e-06 1.000000e+00 3.000000e-06 1.000000e+00 4.000000e-06 1.000000e+00 5.000000e-06 1.000000e+00 6.000000e-06 1.000000e+00 7.000000e-06 1.000000e+00 8.000000e-06 1.000000e+00 9.000000e-06 1.000000e+00 1.000000e-05 1.000000e+00 1.100000e-05 1.000000e+00 1.200000e-05 1.000000e+00 1.300000e-05 1.000000e+00 1.400000e-05 1.000000e+00 1.500000e-05 1.000000e+00 1.600000e-05 1.000000e+00 1.700000e-05 1.000000e+00 1.800000e-05 1.000000e+00 1.900000e-05 1.000000e+00 2.000000e-05 1.000000e+00 2.100000e-05 1.000000e+00 2.200000e-05 1.000000e+00 2.300000e-05 1.000000e+00 2.400000e-05 1.000000e+00 2.500000e-05 1.000000e+00 2.600000e-05 1.000000e+00 2.700000e-05 1.000000e+00 2.800000e-05 1.000000e+00 2.900000e-05 1.000000e+00 3.000000e-05 1.000000e+00 3.100000e-05 1.000000e+00 3.200000e-05 1.000000e+00 3.300000e-05 1.000000e+00 3.400000e-05 1.000000e+00 3.500000e-05 1.000000e+00 3.600000e-05 1.000000e+00 3.700000e-05 1.000000e+00 3.800000e-05 1.000000e+00 3.900000e-05 1.000000e+00 4.000000e-05 1.000000e+00 4.100000e-05 1.000000e+00 4.200000e-05 1.000000e+00 4.300000e-05 1.000000e+00 4.400000e-05 1.000000e+00 4.500000e-05 1.000000e+00 4.600000e-05 1.000000e+00 4.700000e-05 1.000000e+00 4.800000e-05 1.000000e+00 4.900000e-05 1.000000e+00 5.000000e-05 1.000000e+00 5.100000e-05 1.000000e+00 5.200000e-05 1.000000e+00 5.300000e-05 1.000000e+00 5.400000e-05 1.000000e+00 5.500000e-05 1.000000e+00 5.600000e-05 1.000000e+00 5.700000e-05 1.000000e+00 5.800000e-05 1.000000e+00 5.900000e-05 1.000000e+00 6.000000e-05 1.000000e+00 6.100000e-05 1.000000e+00 6.200000e-05 1.000000e+00 6.300000e-05 1.000000e+00 6.400000e-05 1.000000e+00 6.500000e-05 1.000000e+00 6.600000e-05 1.000000e+00 6.700000e-05 1.000000e+00 6.800000e-05 1.000000e+00 6.900000e-05 1.000000e+00 7.000000e-05 1.000000e+00 7.100000e-05 1.000000e+00 7.200000e-05 1.000000e+00 7.300000e-05 1.000000e+00 7.400000e-05 1.000000e+00 7.500000e-05 1.000000e+00 7.600000e-05 1.000000e+00 7.700000e-05 1.000000e+00 7.800000e-05 1.000000e+00 7.900000e-05 1.000000e+00 8.000000e-05 1.000000e+00 8.100000e-05 1.000000e+00 8.200000e-05 1.000000e+00 8.300000e-05 1.000000e+00 8.400000e-05 1.000000e+00 8.500000e-05 1.000000e+00 8.600000e-05 1.000000e+00 8.700000e-05 1.000000e+00 8.800000e-05 1.000000e+00 8.900000e-05 1.000000e+00 9.000000e-05 1.000000e+00 9.100000e-05 1.000000e+00 9.200000e-05 1.000000e+00 9.300000e-05 1.000000e+00 9.400000e-05 1.000000e+00 9.500000e-05 1.000000e+00 9.600000e-05 1.000000e+00 9.700000e-05 1.000000e+00 9.800000e-05 1.000000e+00 9.900000e-05 1.000000e+00 1.000000e-04 1.000000e+00 1.010000e-04 1.000000e+00 1.020000e-04 1.000000e+00 1.030000e-04 1.000000e+00 1.040000e-04 1.000000e+00 1.050000e-04 1.000000e+00 1.060000e-04 1.000000e+00 1.070000e-04 1.000000e+00 1.080000e-04 1.000000e+00 1.090000e-04 1.000000e+00 1.100000e-04 1.000000e+00 1.110000e-04 1.000000e+00 1.120000e-04 1.000000e+00 1.130000e-04 1.000000e+00 1.140000e-04 1.000000e+00 1.150000e-04 1.000000e+00 1.160000e-04 1.000000e+00 1.170000e-04 1.000000e+00 1.180000e-04 1.000000e+00 1.190000e-04 1.000000e+00 1.200000e-04 1.000000e+00 1.210000e-04 1.000000e+00 1.220000e-04 1.000000e+00 1.230000e-04 1.000000e+00 1.240000e-04 1.000000e+00 1.250000e-04 1.000000e+00 1.260000e-04 1.000000e+00 1.270000e-04 1.000000e+00 1.280000e-04 1.000000e+00 1.290000e-04 1.000000e+00 1.300000e-04 1.000000e+00 1.310000e-04 1.000000e+00 1.320000e-04 1.000000e+00 1.330000e-04 1.000000e+00 1.340000e-04 1.000000e+00 1.350000e-04 1.000000e+00 1.360000e-04 1.000000e+00 1.370000e-04 1.000000e+00 1.380000e-04 1.000000e+00 1.390000e-04 1.000000e+00 1.400000e-04 1.000000e+00 1.410000e-04 1.000000e+00 1.420000e-04 1.000000e+00 1.430000e-04 1.000000e+00 1.440000e-04 1.000000e+00 1.450000e-04 1.000000e+00 1.460000e-04 1.000000e+00 1.470000e-04 1.000000e+00 1.480000e-04 1.000000e+00 1.490000e-04 1.000000e+00 1.500000e-04 1.000000e+00 1.510000e-04 1.000000e+00 1.520000e-04 1.000000e+00 1.530000e-04 1.000000e+00 1.540000e-04 1.000000e+00 1.550000e-04 1.000000e+00 1.560000e-04 1.000000e+00 1.570000e-04 1.000000e+00 1.580000e-04 1.000000e+00 1.590000e-04 1.000000e+00 1.600000e-04 1.000000e+00 1.610000e-04 1.000000e+00 1.620000e-04 1.000000e+00 1.630000e-04 1.000000e+00 1.640000e-04 1.000000e+00 1.650000e-04 1.000000e+00 1.660000e-04 1.000000e+00 1.670000e-04 1.000000e+00 1.680000e-04 1.000000e+00 1.690000e-04 1.000000e+00 1.700000e-04 1.000000e+00 1.710000e-04 1.000000e+00 1.720000e-04 1.000000e+00 1.730000e-04 1.000000e+00 1.740000e-04 1.000000e+00 1.750000e-04 1.000000e+00 1.760000e-04 1.000000e+00 1.770000e-04 1.000000e+00 1.780000e-04 1.000000e+00 1.790000e-04 1.000000e+00 1.800000e-04 1.000000e+00 1.810000e-04 1.000000e+00 1.820000e-04 1.000000e+00 1.830000e-04 1.000000e+00 1.840000e-04 1.000000e+00 1.850000e-04 1.000000e+00 1.860000e-04 1.000000e+00 1.870000e-04 1.000000e+00 1.880000e-04 1.000000e+00 1.890000e-04 1.000000e+00 1.900000e-04 1.000000e+00 1.910000e-04 1.000000e+00 1.920000e-04 1.000000e+00 1.930000e-04 1.000000e+00 1.940000e-04 1.000000e+00 1.950000e-04 1.000000e+00 1.960000e-04 1.000000e+00 1.970000e-04 1.000000e+00 1.980000e-04 1.000000e+00 1.990000e-04 1.000000e+00)
X1 n1 n8 n7 irf520
D1 n1 n2 DI_1N4007
C1 n2 n11 12e-6
R8 n11 n1 25
R1 n7 0 2
R3 n12 n2 15
VgenPWMVAR n8 0 PWL(0.000000e+00 5.200000e+00 1.000000e-06 5.200000e+00 2.000000e-06 5.200000e+00 3.000000e-06 5.200000e+00 4.000000e-06 5.200000e+00 5.000000e-06 5.200000e+00 6.000000e-06 5.200000e+00 7.000000e-06 5.200000e+00 8.000000e-06 5.200000e+00 9.000000e-06 5.200000e+00 1.000000e-05 5.200000e+00 1.100000e-05 5.200000e+00 1.200000e-05 5.200000e+00 1.300000e-05 5.200000e+00 1.400000e-05 5.200000e+00 1.500000e-05 5.200000e+00 1.600000e-05 5.200000e+00 1.700000e-05 5.200000e+00 1.800000e-05 5.200000e+00 1.900000e-05 5.200000e+00 2.000000e-05 5.200000e+00 2.100000e-05 5.200000e+00 2.200000e-05 5.200000e+00 2.300000e-05 5.200000e+00 2.400000e-05 5.200000e+00 2.500000e-05 5.200000e+00 2.600000e-05 5.200000e+00 2.700000e-05 5.200000e+00 2.800000e-05 5.200000e+00 2.900000e-05 5.200000e+00 3.000000e-05 5.200000e+00 3.100000e-05 5.200000e+00 3.200000e-05 5.200000e+00 3.300000e-05 5.200000e+00 3.400000e-05 5.200000e+00 3.500000e-05 5.200000e+00 3.600000e-05 5.200000e+00 3.700000e-05 5.200000e+00 3.800000e-05 5.200000e+00 3.900000e-05 5.200000e+00 4.000000e-05 5.200000e+00 4.100000e-05 5.200000e+00 4.200000e-05 5.200000e+00 4.300000e-05 5.200000e+00 4.400000e-05 5.200000e+00 4.500000e-05 5.200000e+00 4.600000e-05 5.200000e+00 4.700000e-05 5.200000e+00 4.800000e-05 5.200000e+00 4.900000e-05 5.200000e+00 5.000000e-05 5.200000e+00 5.100000e-05 5.200000e+00 5.200000e-05 5.200000e+00 5.300000e-05 5.200000e+00 5.400000e-05 5.200000e+00 5.500000e-05 5.200000e+00 5.600000e-05 5.200000e+00 5.700000e-05 5.200000e+00 5.800000e-05 5.200000e+00 5.900000e-05 5.200000e+00 6.000000e-05 5.200000e+00 6.100000e-05 5.200000e+00 6.200000e-05 5.200000e+00 6.300000e-05 5.200000e+00 6.400000e-05 5.200000e+00 6.500000e-05 5.200000e+00 6.600000e-05 5.200000e+00 6.700000e-05 5.200000e+00 6.800000e-05 5.200000e+00 6.900000e-05 5.200000e+00 7.000000e-05 5.200000e+00 7.100000e-05 5.200000e+00 7.200000e-05 5.200000e+00 7.300000e-05 5.200000e+00 7.400000e-05 5.200000e+00 7.500000e-05 5.200000e+00 7.600000e-05 5.200000e+00 7.700000e-05 5.200000e+00 7.800000e-05 5.200000e+00 7.900000e-05 5.200000e+00 8.000000e-05 5.200000e+00 8.100000e-05 5.200000e+00 8.200000e-05 5.200000e+00 8.300000e-05 5.200000e+00 8.400000e-05 5.200000e+00 8.500000e-05 5.200000e+00 8.600000e-05 5.200000e+00 8.700000e-05 5.200000e+00 8.800000e-05 5.200000e+00 8.900000e-05 5.200000e+00 9.000000e-05 5.200000e+00 9.100000e-05 5.200000e+00 9.200000e-05 5.200000e+00 9.300000e-05 5.200000e+00 9.400000e-05 5.200000e+00 9.500000e-05 5.200000e+00 9.600000e-05 5.200000e+00 9.700000e-05 5.200000e+00 9.800000e-05 5.200000e+00 9.900000e-05 5.200000e+00 1.000000e-04 5.200000e+00 1.010000e-04 5.200000e+00 1.020000e-04 5.200000e+00 1.030000e-04 5.200000e+00 1.040000e-04 5.200000e+00 1.050000e-04 5.200000e+00 1.060000e-04 5.200000e+00 1.070000e-04 5.200000e+00 1.080000e-04 5.200000e+00 1.090000e-04 5.200000e+00 1.100000e-04 5.200000e+00 1.110000e-04 5.200000e+00 1.120000e-04 5.200000e+00 1.130000e-04 5.200000e+00 1.140000e-04 5.200000e+00 1.150000e-04 5.200000e+00 1.160000e-04 5.200000e+00 1.170000e-04 5.200000e+00 1.180000e-04 5.200000e+00 1.190000e-04 5.200000e+00 1.200000e-04 5.200000e+00 1.210000e-04 5.200000e+00 1.220000e-04 5.200000e+00 1.230000e-04 5.200000e+00 1.240000e-04 5.200000e+00 1.250000e-04 5.200000e+00 1.260000e-04 5.200000e+00 1.270000e-04 5.200000e+00 1.280000e-04 5.200000e+00 1.290000e-04 5.200000e+00 1.300000e-04 5.200000e+00 1.310000e-04 5.200000e+00 1.320000e-04 5.200000e+00 1.330000e-04 5.200000e+00 1.340000e-04 5.200000e+00 1.350000e-04 5.200000e+00 1.360000e-04 5.200000e+00 1.370000e-04 5.200000e+00 1.380000e-04 5.200000e+00 1.390000e-04 5.200000e+00 1.400000e-04 5.200000e+00 1.410000e-04 5.200000e+00 1.420000e-04 5.200000e+00 1.430000e-04 5.200000e+00 1.440000e-04 5.200000e+00 1.450000e-04 5.200000e+00 1.460000e-04 5.200000e+00 1.470000e-04 5.200000e+00 1.480000e-04 5.200000e+00 1.490000e-04 5.200000e+00 1.500000e-04 5.200000e+00 1.510000e-04 5.200000e+00 1.520000e-04 5.200000e+00 1.530000e-04 5.200000e+00 1.540000e-04 5.200000e+00 1.550000e-04 5.200000e+00 1.560000e-04 5.200000e+00 1.570000e-04 5.200000e+00 1.580000e-04 5.200000e+00 1.590000e-04 5.200000e+00 1.600000e-04 5.200000e+00 1.610000e-04 5.200000e+00 1.620000e-04 5.200000e+00 1.630000e-04 5.200000e+00 1.640000e-04 5.200000e+00 1.650000e-04 5.200000e+00 1.660000e-04 5.200000e+00 1.670000e-04 5.200000e+00 1.680000e-04 5.200000e+00 1.690000e-04 5.200000e+00 1.700000e-04 5.200000e+00 1.710000e-04 5.200000e+00 1.720000e-04 5.200000e+00 1.730000e-04 5.200000e+00 1.740000e-04 5.200000e+00 1.750000e-04 5.200000e+00 1.760000e-04 5.200000e+00 1.770000e-04 5.200000e+00 1.780000e-04 5.200000e+00 1.790000e-04 5.200000e+00 1.800000e-04 5.200000e+00 1.810000e-04 5.200000e+00 1.820000e-04 5.200000e+00 1.830000e-04 5.200000e+00 1.840000e-04 5.200000e+00 1.850000e-04 5.200000e+00 1.860000e-04 5.200000e+00 1.870000e-04 5.200000e+00 1.880000e-04 5.200000e+00 1.890000e-04 5.200000e+00 1.900000e-04 5.200000e+00 1.910000e-04 5.200000e+00 1.920000e-04 5.200000e+00 1.930000e-04 5.200000e+00 1.940000e-04 5.200000e+00 1.950000e-04 5.200000e+00 1.960000e-04 5.200000e+00 1.970000e-04 5.200000e+00 1.980000e-04 5.200000e+00 1.990000e-04 5.200000e+00)
R2 n8 0 10e3
VMos1 n9 0 25
.param parVgenVAR=1.500000e+01
.param parVbackemfCVAR=-9.351436e-01
.param parLaC=2.000000e-03
.param parRaC=6.910000e+01
.param parVSW1VAR=1.000000e+00
.param parVgenPWMVAR=5.200000e+00
.param icLaC=1.630664e-01
.ic V(n9)=2.500000e+01 V(n11)=5.396183e-01 V(x1.6)=-2.521998e-01 V(x1.11)=-2.521998e-01 V(x1.10)=-4.798411e+00 V(x1.5)=-2.522134e-01 V(x1.4)=0.000000e+00 V(n8)=5.200000e+00 V(n7)=3.369767e-01 V(x1.8)=3.657958e-01 V(x1.7)=5.200000e+00 V(x1.9)=4.015889e-01 V(n10)=1.000000e+00 V(n12)=1.498315e+01 V(n6)=1.500000e+01 V(n2)=1.245583e+01 V(n3)=1.245583e+01 V(n4)=1.165988e+01 V(n1)=4.040708e-01 V(n5)=1.167196e+01
**********MODELS**********
*****MODEL1*****
.model SW1 SW(Ron=0.1 Roff=1Meg Vt=.5 Vh=0)
*****MODEL2*****
.MODEL DI_1N4007 D  ( IS=76.9p RS=42.0m BV=1.00k IBV=5.00u
+ CJO=26.5p  M=0.333 N=1.45 TT=4.32u )
*****MODEL3*****
.SUBCKT irf520 1 2 3
**************************************
*      Model Generated by MODPEX     *
*Copyright(c) Symmetry Design Systems*
*         All Rights Reserved        *
*    UNPUBLISHED LICENSED SOFTWARE   *
*   Contains Proprietary Information *
*      Which is The Property of      *
*     SYMMETRY OR ITS LICENSORS      *
*Commercial Use or Resale Restricted *
*   by Symmetry License Agreement    *
**************************************
* Model generated on Apr 24, 96
* Model format: SPICE3
* Symmetry POWER MOS Model (Version 1.0)
* External Node Designations
* Node 1 -> Drain
* Node 2 -> Gate
* Node 3 -> Source
M1 9 7 8 8 MM L=100u W=100u
* Default values used in MM:
* The voltage-dependent capacitances are
* not included. Other default values are:
*   RS=0 RD=0 LD=0 CBD=0 CBS=0 CGBO=0
.MODEL MM NMOS LEVEL=1 IS=1e-32
+VTO=3.61397 LAMBDA=0.00572642 KP=3.9143
+CGSO=3.28344e-06 CGDO=1.0112e-11
RS 8 3 0.171045
D1 3 1 MD
.MODEL MD D IS=7.10668e-11 RS=0.0302634 N=1.21428 BV=100
+IBV=0.00025 EG=1 XTI=2.99378 TT=2.27818e-09
+CJO=5.01988e-10 VJ=0.565258 M=0.378444 FC=0.5
RDS 3 1 4e+06
RD 9 1 0.01473
RG 2 7 1.34402
D2 4 5 MD1
* Default values used in MD1:
*   RS=0 EG=1.11 XTI=3.0 TT=0
*   BV=infinite IBV=1mA
.MODEL MD1 D IS=1e-32 N=50
+CJO=4.14565e-10 VJ=0.5 M=0.640575 FC=1e-08
D3 0 5 MD2
* Default values used in MD2:
*   EG=1.11 XTI=3.0 TT=0 CJO=0
*   BV=infinite IBV=1mA
.MODEL MD2 D IS=1e-10 N=0.4 RS=3e-06
RL 5 10 1
FI2 7 9 VFI2 -1
VFI2 4 0 0
EV16 10 0 9 7 1
CAP 11 10 6.23795e-10
FI1 7 9 VFI1 -1
VFI1 11 6 0
RCAP 6 10 1
D4 0 6 MD3
* Default values used in MD3:
*   EG=1.11 XTI=3.0 TT=0 CJO=0
*   RS=0 BV=infinite IBV=1mA
.MODEL MD3 D IS=1e-10 N=0.4
.ENDS
